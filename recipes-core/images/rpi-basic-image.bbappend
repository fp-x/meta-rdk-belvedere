
RDEPENDS_${PN} += " \
	CcspCommonLibrary \
	hal \
	CcspCMAgent \
	CcspCr \
	CcspLMLite \
	CcspMisc \
	CcspMtaAgent \
	CcspPandM \
	CcspPsm \
	CcspSnmpPa \
	CcspTr069Pa \
	CcspWifiAgent \
	RebootManager \
	TestAndDiagnostic \
	"
